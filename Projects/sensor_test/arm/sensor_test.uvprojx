# Keil uVision project sensor_test.uvprojx, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310 DEBUG SPI_MASTER_0_ENABLE
  c include: ..\..\..\Include;..\..\..\Include\sdk_soc;..\..\..\Include\app_common;..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: main.c
    ../../../Source/: keil_arm_uv4.lnt
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../Source/spi_master/: spi_master.c
    ../../../Source/nrf_delay/: nrf_delay.c
    ../../../Source/sdk_soc/: nrf_soc.c
    ../../../Source/simple_uart/: simple_uart.c
    ../: mpu_9250.c ADS8320.c ltc_2942.c
    ../../../Source/twi_master/: twi_hw_master.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310 DEBUG SPI_MASTER_0_ENABLE SPI_MASTER_1_ENABLE
  c include: ..\..\..\..\Include;..\..\..\..\Include\sdk_soc;..\..\..\..\Include\app_common;..\
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
